# Keil uVision project alk8266_wifi.uvprojx, settings and files
target vr_glass (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: alk8266_wifi +hex
  AfterMake: fromelf --bin --output Objects\alk8266_wifi.bin Objects\alk8266_wifi.axf
  c flags: Optim=4 oTime=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\driver\imu;..\peripheral\include;..\system;..\driver\sensor;..\driver\M8266WIFI
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xb000
  memory RVCT6: RAM 0xb000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group app
    ../app/: main.c startup.s
  group system
    ../system/: delay.c
  group driver
    ../driver/imu/: bma2x2.c bma2x2_support.c bmg160.c bmg160_support.c bmm150.c bmm150_common.c bmm150_support.c imu.c
    ../driver/sensor/: ov9281.c ov9282.c
  group peripheral
    ../peripheral/src/gpio/: gpio.c
    ../peripheral/src/i2c/: i2c.c
    ../peripheral/src/spi/: spi.c ssp.c
    ../peripheral/src/timer/: timer.c
    ../peripheral/src/uart/: serial.c uart.c
  group wifi
    ../driver/M8266WIFI/: M8266HostIf.c M8266WIFIDrv_STM32F1xx.a M8266WIFI_ops.c test_m8266wifi.c
